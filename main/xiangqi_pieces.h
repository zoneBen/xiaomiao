#ifndef XIANGQI_PIECES_H
#define XIANGQI_PIECES_H

#include <stdint.h>

// 棋子大小：12x12 像素
#define XIANGQI_PIECE_WIDTH 12
#define XIANGQI_PIECE_HEIGHT 12

// ============= 红方棋子位图 =============
// 从PNG图片自动生成

// King (帅)
static const uint8_t xiangqi_piece_king_red[] = {
    0x00, 0x00,
    0x00, 0x80,
    0x10, 0x80,
    0x57, 0xe0,
    0x54, 0xa0,
    0x55, 0x20,
    0x55, 0x20,
    0x15, 0xa0,
    0x31, 0x40,
    0x02, 0x60,
    0x00, 0x00,
    0x00, 0x00,
};

// Advisor (仕)
static const uint8_t xiangqi_piece_advisor_red[] = {
    0x00, 0x00,
    0x11, 0x00,
    0x21, 0x00,
    0x6f, 0xe0,
    0x21, 0x00,
    0x21, 0x00,
    0x21, 0x00,
    0x21, 0x00,
    0x2f, 0xe0,
    0x00, 0x00,
    0x00, 0x00,
    0x00, 0x00,
};

// Elephant (相)
static const uint8_t xiangqi_piece_elephant_red[] = {
    0x00, 0x00,
    0x00, 0x00,
    0x27, 0xc0,
    0x74, 0x40,
    0x27, 0xc0,
    0x64, 0x40,
    0x37, 0xc0,
    0x24, 0x40,
    0x27, 0xc0,
    0x00, 0x00,
    0x00, 0x00,
    0x00, 0x00,
};

// Horse (马)
static const uint8_t xiangqi_piece_horse_red[] = {
    0x00, 0x00,
    0x00, 0x00,
    0x3f, 0x80,
    0x10, 0x80,
    0x10, 0x80,
    0x10, 0x80,
    0x1f, 0xc0,
    0x00, 0x40,
    0x3e, 0x40,
    0x00, 0x40,
    0x1f, 0xc0,
    0x00, 0x00,
};

// Chariot (车)
static const uint8_t xiangqi_piece_chariot_red[] = {
    0x00, 0x00,
    0x08, 0x00,
    0x3f, 0xc0,
    0x08, 0x00,
    0x19, 0x00,
    0x19, 0x00,
    0x1f, 0xc0,
    0x01, 0x00,
    0x3f, 0xc0,
    0x01, 0x00,
    0x01, 0x00,
    0x00, 0x00,
};

// Cannon (炮)
static const uint8_t xiangqi_piece_cannon_red[] = {
    0x00, 0x00,
    0x03, 0x00,
    0x26, 0x00,
    0x77, 0xe0,
    0x20, 0x20,
    0x37, 0xa0,
    0x34, 0xa0,
    0x2f, 0xa0,
    0x44, 0x00,
    0x07, 0xe0,
    0x00, 0x00,
    0x00, 0x00,
};

// Pawn (兵)
static const uint8_t xiangqi_piece_pawn_red[] = {
    0x00, 0x00,
    0x02, 0x00,
    0x06, 0x00,
    0x3c, 0x00,
    0x20, 0x00,
    0x3f, 0x00,
    0x21, 0x00,
    0x21, 0x00,
    0x7f, 0xc0,
    0x12, 0x00,
    0x33, 0x00,
    0x00, 0x00,
};

// ============= 黑方棋子位图 =============
// 从PNG图片自动生成

// King (将)
static const uint8_t xiangqi_piece_king_black[] = {
    0x00, 0x00,
    0x22, 0x00,
    0x27, 0x00,
    0x29, 0x00,
    0x65, 0x00,
    0x22, 0x00,
    0x2f, 0xc0,
    0x61, 0x00,
    0x25, 0x00,
    0x21, 0x00,
    0x23, 0x00,
    0x00, 0x00,
};

// Advisor (士)
static const uint8_t xiangqi_piece_advisor_black[] = {
    0x00, 0x00,
    0x11, 0x00,
    0x21, 0x00,
    0x6f, 0xe0,
    0x21, 0x00,
    0x21, 0x00,
    0x21, 0x00,
    0x21, 0x00,
    0x2f, 0xe0,
    0x00, 0x00,
    0x00, 0x00,
    0x00, 0x00,
};

// Elephant (象)
static const uint8_t xiangqi_piece_elephant_black[] = {
    0x00, 0x00,
    0x00, 0x00,
    0x27, 0xc0,
    0x74, 0x40,
    0x27, 0xc0,
    0x64, 0x40,
    0x37, 0xc0,
    0x24, 0x40,
    0x27, 0xc0,
    0x00, 0x00,
    0x00, 0x00,
    0x00, 0x00,
};

// Horse (马)
static const uint8_t xiangqi_piece_horse_black[] = {
    0x00, 0x00,
    0x00, 0x00,
    0x3f, 0x80,
    0x10, 0x80,
    0x10, 0x80,
    0x10, 0x80,
    0x1f, 0xc0,
    0x00, 0x40,
    0x3e, 0x40,
    0x00, 0x40,
    0x1f, 0xc0,
    0x00, 0x00,
};

// Chariot (车)
static const uint8_t xiangqi_piece_chariot_black[] = {
    0x00, 0x00,
    0x08, 0x00,
    0x3f, 0xc0,
    0x08, 0x00,
    0x19, 0x00,
    0x19, 0x00,
    0x1f, 0xc0,
    0x01, 0x00,
    0x3f, 0xc0,
    0x01, 0x00,
    0x01, 0x00,
    0x00, 0x00,
};

// Cannon (炮)
static const uint8_t xiangqi_piece_cannon_black[] = {
    0x00, 0x00,
    0x03, 0x00,
    0x26, 0x00,
    0x77, 0xe0,
    0x20, 0x20,
    0x37, 0xa0,
    0x34, 0xa0,
    0x2f, 0xa0,
    0x44, 0x00,
    0x07, 0xe0,
    0x00, 0x00,
    0x00, 0x00,
};

// Pawn (卒)
static const uint8_t xiangqi_piece_pawn_black[] = {
    0x00, 0x00,
    0x04, 0x00,
    0x3f, 0x80,
    0x15, 0x00,
    0x2e, 0x80,
    0x7f, 0xc0,
    0x04, 0x00,
    0x04, 0x00,
    0x04, 0x00,
    0x04, 0x00,
    0x04, 0x00,
    0x00, 0x00,
};

// ==================== 棋子查找表 ====================

// 红方棋子
static const uint8_t* xiangqi_red_pieces[] = {
    NULL,
    xiangqi_piece_king_red,
    xiangqi_piece_advisor_red,
    xiangqi_piece_elephant_red,
    xiangqi_piece_horse_red,
    xiangqi_piece_chariot_red,
    xiangqi_piece_cannon_red,
    xiangqi_piece_pawn_red,
};

// 黑方棋子
static const uint8_t* xiangqi_black_pieces[] = {
    NULL,
    xiangqi_piece_king_black,
    xiangqi_piece_advisor_black,
    xiangqi_piece_elephant_black,
    xiangqi_piece_horse_black,
    xiangqi_piece_chariot_black,
    xiangqi_piece_cannon_black,
    xiangqi_piece_pawn_black,
};

// 根据棋子类型和颜色获取位图
static inline const uint8_t* xiangqi_get_piece_bitmap(XiangqiPieceType type, XiangqiColor color)
{
    if (type == XIANGQI_PIECE_NONE) return NULL;

    if (color == XIANGQI_COLOR_RED) {
        if (type <= XIANGQI_PIECE_PAWN) {
            return xiangqi_red_pieces[type];
        }
    } else if (color == XIANGQI_COLOR_BLACK) {
        if (type >= XIANGQI_PIECE_KING_B && type <= XIANGQI_PIECE_PAWN_B) {
            return xiangqi_black_pieces[type - XIANGQI_PIECE_KING_B];
        }
    }
    return NULL;
}

#endif // XIANGQI_PIECES_H
